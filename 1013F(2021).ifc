Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-06T15:26:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 06 15:26:00 2021 * Host: DESKTOP-JA1LLOH * Database: C:\Users\Vlad\AppData\Local\Temp\{7762F518-E00D-42D4-8CED-2DA608871A98}\ifc * Database version: 5507 * Database creation date: Fri Aug 06 15:25:59 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 06 15:25:59 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 06 15:25:59 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1013F Washbasin faucet with washing machine valve, 1013F(2021):1013F Washbasin faucet with washing machine valve:343265
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; Projection: 133 mm
Type - General - Author: BIMstone; BIMObjectName: 1013F(2021); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 22/07/2021
Type - Green Building Properties - Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150098628; EN Standard: EN 817; LVI Number: 6110354; Noise Class: I (ISO 3822)
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/1013F; Catalog Drawing URL: http://static.oras.com/catdrw/1013F; Class: Single lever;; Dimension Drawing URL: http://static.oras.com/dimdrw/1013F; FDV Document URL: http://www.oras.com/datasheet/1013F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1013F; Group: Washbasin faucets; Manufacturer: Oras; Market: FIN; Model: 1013F Washbasin faucet with washing machine valve; Name_en: 1013F Washbasin faucet with washing machine valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 590 x 290 x 65; Package Weight: 1.56 kg; Product Code: 1013F; Product Datasheet: http://www.oras.com/datasheet/1013F/en; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1013F; Product URL: http://static.oras.com/1013F; Technical DataSheet URL: http://www.oras.com/datasheet/1013F/en; Type Name: 1013F Washbasin faucet with washing machine valve
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Aerator: CASCADE®; Connection: FlexibleInletPipes; Connection Size: G3/8; Flow Rate At 300kPa: 0.00670979 m3/s; Installation and Maintenance: http://static.oras.com/manual/1013F; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 40Cartridge; Mounting Holes: 1MountingHole; Pressure Loss With Flow 02ls: 90000 Pa; Spare Parts: http://static.oras.com/sp/1013F; Spout Swivel Range: 120° (40° / 80°); Spout Type: Swivel spout; Temperature: Temperature limiter
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1013F(2021); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1013F; Name: 1013F Washbasin faucet with washing machine valve; ReplacementCost: n/a; Shape: Sculptured; Size: 55x175x165 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0474425 m2; Volume: 0.00152746 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1013F(2021): 1013F Washbasin faucet with washing machine valve; Family and Type: 1013F(2021): 1013F Washbasin faucet with washing machine valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1013F(2021): 1013F Washbasin faucet with washing machine valve; Type Id: 1013F(2021): 1013F Washbasin faucet with washing machine valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
